# Keil uVision project Project.uvprojx, settings and files
target STM32L151CBT6A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151CBTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L151xB,USE_HAL_DRIVER,REGION_EU_868,REGION_US_915,LR1110,LR1110_TRANSCEIVER,ENABLE_MODEM_GNSS_FEATURE
  c include: ..\User\Applications;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32L1xx_HAL_Driver\Inc;..\User\segger_rtt;..\User\lora_basic_modem_sdk\lbm_app;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_api;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\device_management;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_config;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_core;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_services;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_services\fragmentation;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_supervisor;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\radio_drivers\lr1110_driver\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\radio_planner\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_hal;..\User\lora_basic_modem_sdk\smtc_board;..\User\lora_basic_modem_sdk\smtc_hal\board;..\User\lora_basic_modem_sdk\smtc_hal\inc;..\User\lora_basic_modem_sdk\smtc_hal\LR1110\Helpers;..\User\lora_basic_modem_sdk\smtc_hal\LR1110\LR1110MB1LxKS\BSP\board;..\User\lora_basic_modem_sdk\smtc_hal\LR1110\radio_drivers_hal;..\User\lora_basic_modem_sdk\smtc_hal\ST\STM32L151xB\inc;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lorawan_api;..\User\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src;..\User\lora_basic_modem_sdk\lora_basics_modem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications/User
    ../User/Applications/: main.c system_stm32l1xx.c stm32l1xx_hal_msp.c stm32l1xx_it.c driver_flash.c key.c led.c system_time.c
  group Device
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xb.s
  group Libraries/STM32L1xx_HAL_Driver
    ../Libraries/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c
  group segger_rtt
    ../User/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group lbm_app
    ../User/lora_basic_modem_sdk/lbm_app/: apps_modem_common.c apps_modem_event.c apps_utilities.c gnss_helpers.c lbm_app.c wifi_helpers.c
  group lbm_modem_core
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_api_lr1110_crypto_engine.c smtc_modem_api_lr1110_system.c smtc_modem_test.c
  group lbm_dm
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/device_management/: dm_downlink.c modem_context.c
  group lbm_lorawan_api
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lorawan_api/: lorawan_api.c
  group lbm_lr1mac
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: region_as_923.c region_au_915.c region_cn_470.c region_cn_470_rp_1_0.c region_eu_868.c region_in_865.c region_kr_920.c region_ru_864.c region_us_915.c region_ww2g4.c smtc_real.c
  group lbm_modem_service
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/modem_services/: fifo_ctrl.c lorawan_certification.c modem_utilities.c smtc_clock_sync.c smtc_modem_services_hal.c
  group lbm_modem_sup
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/modem_supervisor/: modem_supervisor.c
  group lbm_radio_driver
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/radio_drivers/lr1110_driver/src/: lr1110_bootloader.c lr1110_crypto_engine.c lr1110_driver_version.c lr1110_gnss.c lr1110_radio.c lr1110_radio_timings.c lr1110_regmem.c lr1110_system.c lr1110_wifi.c
  group lbm_radio_planner
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/radio_planner/src/: radio_planner.c radio_planner_hal.c
  group lbm_smtc_modem_crypto
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/lr1110_secure_element/: lr1110_se.c
  group lbm_smtc_ral
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_ral/src/: ral_lr1110.c
  group lbm_smtc_ralf
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_ralf/src/: ralf_lr1110.c
  group lbm_smtc_modem_service
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/alc_sync/: alc_sync.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/almanac_update/: almanac_update.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/file_upload/: file_upload.c
    ../User/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/stream/: rose.c stream.c
  group lbm_smtc_hal_port
    ../User/lora_basic_modem_sdk/smtc_hal/LR1110/Helpers/: lr1110_geolocation_helpers.c
    ../User/lora_basic_modem_sdk/smtc_hal/LR1110/LR1110MB1LxKS/BSP/board/: lr1110_mb1lxks_board.c
    ../User/lora_basic_modem_sdk/smtc_hal/LR1110/LR1110MB1LxKS/BSP/ral_bsp/: ral_lr1110_bsp.c
    ../User/lora_basic_modem_sdk/smtc_hal/LR1110/radio_drivers_hal/: lr1110_hal.c
    ../User/lora_basic_modem_sdk/smtc_hal/ST/STM32L151xB/src/: smtc_hal_adc.c smtc_hal_trace.c smtc_hal_watchdog.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_spi.c smtc_hal_lp_timer.c smtc_hal_mcu.c
    ../User/lora_basic_modem_sdk/smtc_hal/ST/STM32L151xB/smtc_modem_hal/: smtc_modem_hal.c
software components: CMSIS:CORE 5.5.0
